# IAR project Beacon_XBY_K60.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 NXP MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: LPLD_K60
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\LPLD\FUNC; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class; ..\app\control\inc; ..\app\control\src; ..\app\debug\inc; ..\app\debug\src; ..\app\device\inc; ..\app\device\src; ..\app\driver\inc; ..\app\driver\src; ..\app\signal\inc; ..\app\signal\src; ..\app\system
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Beacon_XBY_K60.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class; ..\..\..\lib\LPLD\FUNC; D:\Freescale\信标\Beacon_C1 -NXP\project\Beacon_XBY\app\driver\inc; D:\Freescale\信标\Beacon_C1 -NXP\project\Beacon_XBY\app\driver\src; D:\Freescale\信标\Beacon_C1 -NXP\project\Beacon_XBY\app\control\inc; D:\Freescale\信标\Beacon_C1 -NXP\project\Beacon_XBY\app\control\src; D:\Freescale\信标\Beacon_C1 -NXP\project\Beacon_XBY\app\debug\inc; D:\Freescale\信标\Beacon_C1 -NXP\project\Beacon_XBY\app\debug\src; D:\Freescale\信标\Beacon_C1 -NXP\project\Beacon_XBY\app\device\src; D:\Freescale\信标\Beacon_C1 -NXP\project\Beacon_XBY\app\device\inc; D:\Freescale\信标\Beacon_C1 -NXP\project\Beacon_XBY\app\signal\inc; D:\Freescale\信标\Beacon_C1 -NXP\project\Beacon_XBY\app\signal\src; D:\Freescale\信标\Beacon_C1 -NXP\project\Beacon_XBY\app\system
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  OBJCOPY.OOCOutputFile: Beacon_XBY_K60.bin
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_BOOT_K60DN512.icf
  group app
    ../app/: Beacon_XBY.c k60_card.h
  group app/control/inc
    ../app/control/inc/: direction.h speedfast.h
  group app/control/src
    ../app/control/src/: direction.c speedfast.c
  group app/debug/inc
    ../app/debug/inc/: beep.h car_test.h dir_kbi.h display_image.h flash.h infrared_decode.h led.h oled.h scope.h slave_computer.h switch.h tele.h
  group app/debug/src
    ../app/debug/src/: beep.c car_test.c dir_kbi.c display_image.c flash.c infrared_decode.c led.c oled.c scope.c slave_computer.c switch.c tele.c
  group app/device/inc
    ../app/device/inc/: camera_digital.h encoder.h FIRE_OV7725_Eagle.h FIRE_OV7725_REG.h motor.h mpu6050.h servo.h
  group app/device/src
    ../app/device/src/: camera_digital.c encoder.c FIRE_OV7725_Eagle.c motor.c MPU6050.c servo.c
  group app/driver/inc
    ../app/driver/inc/: adc.h gpio.h GPT.h I2C.h nvic.h pit.h pwm.h rtc.h uart.h VCAN_SCCB.h
  group app/driver/src
    ../app/driver/src/: adc.c gpio.c GPT.c I2C.c Nvic.c PIT.c PWM.c rtc.c UART.c VCAN_SCCB.c
  group app/signal/inc
    ../app/signal/inc/: avoidance.h directional.h display.h image.h inductor.h measure.h route.h
  group app/signal/src
    ../app/signal/src/: avoidance.c directional.c display.c image.c inductor.c measure.c route.c
  group app/system
    ../app/system/: car_info.c general.c general.h include.h init.c init.h interrupt.c interrupt.h
  group lib/common
    ../../../lib/common/: alloc.c assert.c assert.h common.h io.c io.h printf.c queue.c queue.h relocate.c relocate.h stdlib.c stdlib.h uif.c uif.h
  group lib/CPU
    ../../../lib/CPU/: MK60DZ10.h startup_K60.s system_MK60DZ10.c system_MK60DZ10.h
  group lib/LPLD
    ../../../lib/LPLD/: LPLD_Drivers.h
  group lib/LPLD/DEV
    ../../../lib/LPLD/DEV/: DEV_DiskIO.c DEV_DiskIO.h DEV_LCD.c DEV_LCD.h DEV_MAG3110.c DEV_MAG3110.h DEV_MMA7660.c DEV_MMA7660.h DEV_MMA8451.c DEV_MMA8451.h DEV_Nrf24L01.c DEV_Nrf24L01.h DEV_SCCB.c DEV_SCCB.h DEV_SDRAM.c DEV_SDRAM.h DEV_Touchscreen.c DEV_Touchscreen.h Font_ASC.h
  group lib/LPLD/FUNC
    ../../../lib/LPLD/FUNC/: TimeStamp.c TimeStamp.h
  group lib/LPLD/HW
    ../../../lib/LPLD/HW/: HW_ADC.c HW_ADC.h HW_CAN.c HW_CAN.h HW_DAC.c HW_DAC.h HW_DMA.c HW_DMA.h HW_ENET.c HW_ENET.h HW_FLASH.c HW_FLASH.h HW_FLEXBUS.c HW_FLEXBUS.h HW_FTM.c HW_FTM.h HW_GPIO.c HW_GPIO.h HW_I2C.c HW_I2C.h HW_LPTMR.c HW_LPTMR.h HW_MCG.c HW_MCG.h HW_NVIC.c HW_NVIC.h HW_PDB.c HW_PDB.h HW_PIT.c HW_PIT.h HW_RTC.c HW_RTC.h HW_SDHC.c HW_SDHC.h HW_SPI.c HW_SPI.h HW_SYSTICK.c HW_SYSTICK.h HW_TSI.c HW_TSI.h HW_UART.c HW_UART.h HW_USB.c HW_USB.h HW_WDOG.c HW_WDOG.h
